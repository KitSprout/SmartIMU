# Keil uVision project ProjNRF5x.uvprojx, settings and files
target NRF52810 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: NRF52810 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52810_XXAA, ARM_MATH_CM4
  c include: ..\;..\Libraries;..\Libraries\integration\nrfx;..\Libraries\integration\nrfx\legacy;..\Libraries\modules\nrfx;..\Libraries\modules\nrfx\drivers\include;..\Libraries\modules\nrfx\hal;..\Libraries\modules\nrfx\mdk;..\Libraries\components;..\Libraries\components\libraries;..\Libraries\components\drivers_nrf;..\Program
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group CMSIS
    ../Libraries/modules/nrfx/mdk/: arm_startup_nrf52810.s system_nrf52810.c
  group Driver
    ../Program/drivers/: nrf5x_clock.c nrf5x_delay.c nrf5x_timer.c nrf5x_uarte.c nrf5x_radio.c
    ../Program/: nrf5x_conf.h
  group Program
    ../Program/: main.c nrf5x_bsp.c nrf5x_it.c boardConfig.h
  group Module
    ../Program/modules/: serial.c kSerial.c
  group Algorithm
    ../Program/algorithms/: mathUnit.c
software components: CMSIS:CORE 5.1.1
