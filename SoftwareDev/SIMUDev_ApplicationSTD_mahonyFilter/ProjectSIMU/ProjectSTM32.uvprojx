# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F405R (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405R
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40XX, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/: system_stm32f4xx.c startup_stm32f40xx.s
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c
    ../Program/: stm32f4xx_conf.h
  group Driver
    ../Program/drivers/: stm32f4_delay.c stm32f4_usart.c stm32f4_spi.c
  group Program
    ../Program/: main.c simuDev_bsp.c simuDev_it.c
  group Module
    ../Program/modules/: serial.c kSerial.c imu.c mpu9250.c
  group Algorithm
    ../Program/algorithms/: string.c quaternion.c mahonyFilter.c
