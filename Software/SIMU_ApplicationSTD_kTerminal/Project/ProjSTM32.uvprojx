# Keil uVision project ProjSTM32.uvprojx, settings and files
target STM32F412R (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F412RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F412R
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM4, __FPU_PRESENT = 1, STM32F412xG
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f412xg.s system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c
    ../Program/: stm32f4xx_conf.h
  group Driver
    ../Program/drivers/: stm32f4_delay.c stm32f4_usart.c stm32f4_spi.c
    ../Program/: boardConfig.h
  group Program
    ../Program/: main.c stm32f4xx_bsp.c stm32f4xx_it.c
  group Application
    ../Program/applications/: kTerminal.c
  group Module
    ../Program/modules/: serial.c imu.c mpu9250.c
  group Algorithm
    ../Program/algorithms/: string.c
