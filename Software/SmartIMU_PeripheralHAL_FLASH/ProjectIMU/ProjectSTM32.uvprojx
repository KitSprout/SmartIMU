# Keil uVision project ProjectSTM32.uvprojx, settings and files
target STM32F411CE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F446R
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F411xE, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\STM32F4xx_HAL_Driver\Src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f411xe.s system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c
    ../Program/: stm32f4xx_hal_conf.h
  group Driver
    ../Program/drivers/: stm32f4_msp.c stm32f4_delay.c stm32f4_flash.c
  group Program
    ../Program/: main.c smartimu.c smartimu_it.c smartimu_bsp.c
  group Algorithm
    ../Program/algorithms/: algorithm_compare.c
